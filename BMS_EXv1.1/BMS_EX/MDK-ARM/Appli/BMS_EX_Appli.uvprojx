# Keil uVision project BMS_EX_Appli.uvprojx, settings and files
target BMS_EX_Debug (6240000::V6.24::ARMCLANG)
  device: STM32N647X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.2.0
  cpu: IRAM(0x34080000-0x341FFFFF) IROM(0x34000400-0x3407FFFF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: BMS_EX_Debug +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N647xx,DEBUG,USE_FULL_ASSERT
  c include: ../../Appli/Core/Inc;../../Secure_nsclib;../../Drivers/STM32N6xx_HAL_Driver/Inc;../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Include;..\..\BSP;..\..\BSP\HyperRAM;..\..\BSP\NORFlash
  memory RVCT4: ROM 0x34000400 size 0x7fc00
  memory RVCT9: RAM 0x34080000 size 0x180000
  scatter file: stm32n647xx_LRUN_RAMxspi1.sct
  link misc: --import_cmse_lib_out=../../Secure_nsclib/secure_nsclib.o --entry Reset_Handler
  group Application/MDK-ARM
    ../: startup_stm32n647xx.c
  group Application/User/Appli/Core
    ../../Appli/Core/Src/: main.c stm32n6xx_it.c stm32n6xx_hal_msp.c secure_nsc.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_adc.c stm32n6xx_hal_adc_ex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_cortex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_spi.c stm32n6xx_hal_spi_ex.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_xspi.c
  group Drivers/CMSIS
    ../../Appli/Core/Src/: system_stm32n6xx_s.c
  group BSP
    ../../BSP/: g03_control.c g03_control.h g03_port.c g03_adc_core.c g03_adc_port.c g03_relay_core.c g03_relay_port.c g03_port.h g02_link.c g02_link.h g02_control.c g02_control.h g02_port.c g02_port.h measurement.c measurement.h measurement_core.c measurement_core.h adbms_acquisition.c adbms_acquisition.h adbms1818.c key.c oled_driver.c oled_font.c uart.c adbms1818.h oled_driver.h oled_font.h uart.h
  group HyperRAM
    ../../BSP/HyperRAM/: hyperram.c
  group NORFlash
    ../../BSP/NORFlash/: norflash_xspi.c norflash.c norflash_by25fq128el.c norflash_mx25um25645g.c
target BMS_EX_Release (6230000::V6.23::ARMCLANG)
  device: STM32N647X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.2.0
  cpu: as above
  output: BMS_EX_Release +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N647xx,NDEBUG
  c include: as above
  memory RVCT4: ROM 0x70100400 size 0x1effc00
  memory RVCT9: RAM 0x34080000 size 0x180000
  scatter file: stm32n647xx_ROMxspi2_RAMxspi1.sct
  link misc: as above
target BMS_PWM_Disabled_Debug (6240000::V6.24::ARMCLANG)
  device: STM32N647X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.2.0
  cpu: as above
  output: BMS_PWM_Disabled_Debug +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N647xx,DEBUG,USE_FULL_ASSERT,G03_PWM_DISABLED_BUILD=1,G3R_LIVE_PROFILE_VERIFIED=0
  c include: as above
  asm define: G03_PWM_DISABLED_BUILD=1,G3R_LIVE_PROFILE_VERIFIED=0
  memory RVCT4: ROM 0x34000400 size 0x7fc00
  memory RVCT9: RAM 0x34080000 size 0x180000
  scatter file: stm32n647xx_LRUN_RAMxspi1.sct
  link misc: --import_cmse_lib_out=BMS_PWM_Disabled_Debug\secure_nsclib.o --entry Reset_Handler
  group added to the first target's files
    ../../BSP/: g03_pwm_port.c pwm_oneshot.c
target BMS_PWM_Disabled_Release (6230000::V6.23::ARMCLANG)
  device: STM32N647X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.2.0
  cpu: as above
  output: BMS_PWM_Disabled_Release +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N647xx,NDEBUG,G03_PWM_DISABLED_BUILD=1,G3R_LIVE_PROFILE_VERIFIED=0
  c include: as above
  asm define: G03_PWM_DISABLED_BUILD=1,G3R_LIVE_PROFILE_VERIFIED=0
  memory RVCT4: ROM 0x70100400 size 0x1effc00
  memory RVCT9: RAM 0x34080000 size 0x180000
  scatter file: stm32n647xx_ROMxspi2_RAMxspi1.sct
  link misc: --import_cmse_lib_out=BMS_PWM_Disabled_Release\secure_nsclib.o --entry Reset_Handler
  group added to the first target's files
    ../../BSP/: g03_pwm_port.c pwm_oneshot.c
target BMS_PWM_Power_Debug (6240000::V6.24::ARMCLANG)
  device: STM32N647X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.2.0
  cpu: as above
  output: BMS_PWM_Power_Debug +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N647xx,DEBUG,USE_FULL_ASSERT,G03_PWM_LIVE_BUILD=1,G3R_LIVE_PROFILE_VERIFIED=0
  c include: as above
  asm define: G03_PWM_LIVE_BUILD=1,G3R_LIVE_PROFILE_VERIFIED=0
  memory RVCT4: ROM 0x34000400 size 0x7fc00
  memory RVCT9: RAM 0x34080000 size 0x180000
  scatter file: stm32n647xx_LRUN_RAMxspi1.sct
  link misc: --import_cmse_lib_out=BMS_PWM_Power_Debug\secure_nsclib.o --entry Reset_Handler
  group added to the first target's files
    ../../BSP/: g03_power_port.c pwm_oneshot.c
target BMS_PWM_Power_Release (6230000::V6.23::ARMCLANG)
  device: STM32N647X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.2.0
  cpu: as above
  output: BMS_PWM_Power_Release +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N647xx,NDEBUG,G03_PWM_LIVE_BUILD=1,G3R_LIVE_PROFILE_VERIFIED=0
  c include: as above
  asm define: G03_PWM_LIVE_BUILD=1,G3R_LIVE_PROFILE_VERIFIED=0
  memory RVCT4: ROM 0x70100400 size 0x1effc00
  memory RVCT9: RAM 0x34080000 size 0x180000
  scatter file: stm32n647xx_ROMxspi2_RAMxspi1.sct
  link misc: --import_cmse_lib_out=BMS_PWM_Power_Release\secure_nsclib.o --entry Reset_Handler
  group added to the first target's files
    ../../BSP/: g03_power_port.c pwm_oneshot.c
software components: CMSIS:CORE 5.6.0
